PRINC := "${@int(PRINC) + 1}"

# Build for the overo
TI_PLATFORM_overo = "omap3630"
MODULESLOCATION_overo = "dc_omapfb3_linux"
DEFAULT_PREFERENCE = "1"
