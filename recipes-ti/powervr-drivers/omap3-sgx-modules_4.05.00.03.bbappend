PRINC := "${@int(PRINC) + 1}"
TI_PLATFORM_overo = "omap3630"
MODULESLOCATION_overo = "dc_omapfb3_linux"
