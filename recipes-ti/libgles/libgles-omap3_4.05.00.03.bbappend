PRINC := "${@int(PRINC) + 1}"

# Hack from: http://lists.openembedded.org/pipermail/openembedded-core/2013-April/077746.html
PACKAGE_DEBUG_SPLIT_STYLE = "debug-without-src"
